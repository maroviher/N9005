## N9005XXUGBOJ1/linux_kernel/ahmed/Kconfig
```kconfig
menu "Ahmed options"

config AHMED_NOPRINTK
	bool "Disable printk"
	default n

endmenu
```
